## drivers/input/fingerprint/cdfingerfp/Kconfig
```kconfig
config CDFINGER_FP
	tristate "cdfinger fingerprint driver support"
	help
	  Say Y here to enable cdfinger fingerprint driver support!
```
